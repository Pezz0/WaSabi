gnof
.lib C:\a s d_\orcocan_\ .lib
R1 0 1 100
R2 0 1 200
.op
